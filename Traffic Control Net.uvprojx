# Keil uVision project Traffic Control Net.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Traffic Control Net
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,
  c include: F:\Keil\ARM\CMSIS\RTOS;.\SYSTEM;.\Class;.\USER;.\hard;.\drive;.\app
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./USER/: main.cpp misc.c head.h
  group class
    ./Class/: led.cpp led.h serialport.cpp serialport.h
  group sys
    ./SYSTEM/: delay.c sys.c usart.c
  group hard
    ./hard/: spi_enc28j60.c spi_enc28j60.h font.h lcd.c touch.c touch.h bsp.c bsp.h eeprom.c eeprom.h key.c
  group drive
    ./drive/: enc28j60.c enc28j60.h ip_arp_udp_tcp.c ip_arp_udp_tcp.h
  group app
    ./app/: netserve.h netserve.c
software components: Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:FSMC 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
